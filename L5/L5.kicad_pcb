File: L5/L5.kicad_pcb (KiCad board)
At the start: 2 copper layers, 264 x 32 mm, 1 part

Commit message: Update L5 and L4 layer
Other:
- outline, holes or cut-outs redrawn
